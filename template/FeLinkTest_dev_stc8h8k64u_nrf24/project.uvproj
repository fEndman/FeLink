# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=9
  c include: .\Core\Inc;.\Driver\inc;.\FeLinkDevice;.\FeLinkDevice\micro-ecc;.\NRF24L01
  link misc: REMOVEUNUSED
  group System
    ./: STARTUP.A51
  group Driver
    ./Driver/src/: ADC.c delay.c EEPROM.c GPIO.c spi.c timer.c UART.C WDT.c Exti.c
  group User
    ./Core/Src/: main.c
    ./NRF24L01/: nrf24.c nrf24l01.c
  group FeLink
    ./FeLinkDevice/: felink.c tea.c userio.c
    ./FeLinkDevice/micro-ecc/: uECC.c
